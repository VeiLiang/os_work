# IAR project ARKN141_DEMO.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG=1; NEW_AE; ISP_NEW_VERSION; ISP_NEW_CONT_VERSION; ISP_ERIS_HIST_VERSION; SRGB_320X240=1
  ICCARM.CCDiagSuppress: Pe177,Pa050
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\PowerPac\TCPIP\Inc\; $TOOLKIT_DIR$\PowerPac\RTOS\Inc\; ..\..\ucfs\inc\; ..\..\rtos\inc\; ..\..\rtos\core\; ..\..\include\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ARKN141_DEMO.bin
  ILINK.IlinkOutputFile: ARKN141_DEMO.out
  ILINK.IlinkIcfFile: E:\proj\ARKN141\sw\xspace\proj\ARKN141_DEMO\ark1960.icf
  ILINK.IlinkExtraOptions: --image_input=..\..\rtos\core\rom.bin,_ROM_BIN_,_ROM_SECTION_,32
  ILINK.IlinkAdditionalLibs: ..\..\hwlib\libavcodec.a; ..\..\hwlib\libavformat.a; ..\..\hwlib\libavutil.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
configuration HDMI_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; NEW_AE; ISP_NEW_VERSION; ISP_NEW_CONT_VERSION; ISP_ERIS_HIST_VERSION; HDMI_720P=1
  ICCARM.CCOptLevel: 0
configuration RGB480X272_RAW (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; NEW_AE; ISP_NEW_VERSION; ISP_NEW_CONT_VERSION; ISP_ERIS_HIST_VERSION; RGB_480X272=1; ISP_RAW_ENABLE
  ILINK.IlinkIcfFile: E:\proj\ARKN141\sw\xspace\proj\ARKN141_DEMO\ark1960_RAW.icf
configuration SRGB320X240_RAW (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; SRGB_320X240=1; ISP_3D_DENOISE_SUPPORT=1; SRGB_TYPE=1; ISP_RAW_ENABLE
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\PowerPac\TCPIP\Inc\; $TOOLKIT_DIR$\PowerPac\RTOS\Inc\; ..\..\ucfs\inc\; ..\..\rtos\inc\; ..\..\rtos\core\; ..\..\include\; ..\..\lib\isp\exposure\; ..\..\lib\isp\sensor\; ..\..\lib\isp\
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: rtos.bin
  ILINK.IlinkIcfFile: E:\proj\ARKN141\sw\xspace\proj\ARKN141_DEMO\ark1960_RAW.icf
  ILINK.IlinkExtraOptions: --image_input=..\..\rtos\core\rom.bin,_ROM_BIN_,_ROM_SECTION_,32; --image_input=..\..\rtos\core\dvr.jpg,_DVR_BIN_,_DVR_SECTION_,32
configuration DEMO_SRGB320X240 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; ISP_3D_DENOISE_SUPPORT=1; DEMO_BB=1; SRGB_TYPE=2; SRGB_320X240=1
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: rtos.bin
  ILINK.IlinkIcfFile: arkn141_demo.icf
configuration DEMO_SRGB320X240_UVCPIO (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; SRGB_320X240=1; ISP_3D_DENOISE_SUPPORT=1; DEMO_BB=1; SRGB_TYPE=2; _HDTV_000255_; UVC_PIO
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: rtos.bin
  ILINK.IlinkIcfFile: arkn141_demo.icf
  ILINK.IlinkExtraOptions: as above
configuration DEMO_SRGB320X240_FULL_HIGH_QUALITY (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; ISP_3D_DENOISE_SUPPORT=1; DEMO_BB=1; SRGB_TYPE=2; _HDTV_000255_; SRGB_320X240=1; HIGH_VIDEO_QUALITY=1
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: rtos.bin
  ILINK.IlinkIcfFile: arkn141_demo.icf
  ILINK.IlinkExtraOptions: --image_input=..\..\rtos\core\rom.bin,_ROM_BIN_,_ROM_SECTION_,32; --image_input=..\..\rtos\core\dvr_320X240.jpg,_DVR_BIN_,_DVR_SECTION_,32
configuration DEMO_SRGB320X240_FULL_NORMAL_QUALITY (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; ISP_3D_DENOISE_SUPPORT=1; DEMO_BB=1; SRGB_TYPE=2; _HDTV_000255_; SRGB_320X240=1; NORMAL_VIDEO_QUALITY=1
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\PowerPac\TCPIP\Inc\; $TOOLKIT_DIR$\PowerPac\RTOS\Inc\; ..\..\lib\ucfs\inc\; ..\..\rtos\inc\; ..\..\rtos\core\; ..\..\include\
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: rtos.bin
  ILINK.IlinkIcfFile: arkn141_demo.icf
  ILINK.IlinkExtraOptions: as above
configuration CZS_USB_01 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; ISP_3D_DENOISE_SUPPORT=1; _HDTV_000255_; NORMAL_VIDEO_QUALITY=1; CZS_USB_01=1
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\PowerPac\TCPIP\Inc\; $TOOLKIT_DIR$\PowerPac\RTOS\Inc\; ..\..\lib\ucfs\inc\; ..\..\rtos\inc\; ..\..\rtos\core\; ..\..\include\; ..\..\lib\isp\exposure\; ..\..\lib\isp\sensor\; ..\..\lib\isp\; ..\..\lib\codec\dec\source\inc; ..\..\lib\codec\dec\source\common; ..\..\lib\codec\dec\source\config; ..\..\lib\codec\dec\source\h264high; ..\..\lib\codec\dec\source\h264high\legacy; ..\..\lib\codec\dec\source\jpeg; ..\..\lib\codec\dec\iar\h264high; ..\..\lib\codec\dec\iar\test\common\swhw; ..\..\lib\codec\enc\inc; ..\..\lib\codec\enc\source\common; ..\..\lib\codec\enc\source\camstab; ..\..\lib\codec\enc\source\h264; ..\..\lib\codec\enc\source\jpeg; ..\..\lib\codec\enc\iar\debug_trace; ..\..\lib\codec\enc\iar\memalloc
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: rtos.bin
  ILINK.IlinkIcfFile: arkn141_demo.icf
  ILINK.IlinkExtraOptions: as above
configuration DEV_BB_176 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; ISP_3D_DENOISE_SUPPORT=1; DEV_BB_176=1; SRGB_TYPE=2; _HDTV_000255_; SRGB_320X240=1; NORMAL_VIDEO_QUALITY=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: rtos.bin
  ILINK.IlinkIcfFile: arkn141_demo.icf
  ILINK.IlinkExtraOptions: as above
configuration CZS_USB_01_HDTV_016235 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; ISP_3D_DENOISE_SUPPORT=0; NORMAL_VIDEO_QUALITY=1; CZS_USB_01=1; JLINK_DISABLE
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: rtos.bin
  ILINK.IlinkIcfFile: arkn141_demo.icf
  ILINK.IlinkExtraOptions: as above
configuration DEMO_SRGB_NORMAL_QUALITY_3D_OFF (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; DEMO_BB=1; SRGB_TYPE=2; _HDTV_000255_; SRGB_320X240=1; NORMAL_VIDEO_QUALITY=1; JLINK_DISABLE; ISP_SCALAR_USE_STATIC_FIFO
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\PowerPac\TCPIP\Inc\; $TOOLKIT_DIR$\PowerPac\RTOS\Inc\; ..\..\lib\ucfs\inc\; ..\..\rtos\inc\; ..\..\rtos\core\; ..\..\include\; ..\..\lib\musbstacks\include\; ..\..\lib\musbstacks\include\class\; ..\..\lib\musbstacks\src\cd\; ..\..\lib\musbstacks\src\drivers\hub\; ..\..\lib\musbstacks\src\drivers\msd\; ..\..\lib\musbstacks\src\drivers\uvc\; ..\..\lib\musbstacks\src\drivers\ipod\; ..\..\lib\musbstacks\src\systems\ucos\; ..\..\lib\musbstacks\src\systems\ucos\afs\
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: rtos.bin
  ILINK.IlinkIcfFile: arkn141_demo.icf
  ILINK.IlinkExtraOptions: as above
configuration CZS_USB_01_HDTV_016235_JLINK (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; ISP_3D_DENOISE_SUPPORT=0; NORMAL_VIDEO_QUALITY=1; CZS_USB_01=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: rtos.bin
  ILINK.IlinkIcfFile: arkn141_demo.icf
  ILINK.IlinkExtraOptions: as above
configuration DEMO_SRGB_NORMAL_QUALITY_3D_OFF_JLINK (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; DEMO_BB=1; SRGB_TYPE=2; _HDTV_000255_; SRGB_320X240=1; NORMAL_VIDEO_QUALITY=1; ISP_SCALAR_USE_STATIC_FIFO
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: rtos.bin
  ILINK.IlinkIcfFile: arkn141_demo.icf
  ILINK.IlinkExtraOptions: as above
configuration HONGJING_CVBS_3D_OFF (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; HONGJING_CVBS=1; _HDTV_000255_; NORMAL_VIDEO_QUALITY=1; _SUPPORT_TV_NTSC_; _SUPPORT_TV_PAL_; LCD_SIZE=7; ARKN141_CMOS_SENSOR=4; _XMSYS_UART_SOCKET_SUPPORT_; JLINK_DISABLE; ISP_SCALAR_USE_STATIC_FIFO; FLASH_3MB
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\PowerPac\TCPIP\Inc\; $TOOLKIT_DIR$\PowerPac\RTOS\Inc\; ..\..\lib\ucfs\inc\; ..\..\rtos\inc\; ..\..\rtos\core\; ..\..\include\; ..\..\lib\isp\exposure\; ..\..\lib\isp\sensor\; ..\..\lib\isp\
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: rtos.bin
  ILINK.IlinkIcfFile: arkn141_hongjing_cvbs.icf
  ILINK.IlinkExtraOptions: as above
configuration DEV_OTG (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; DEMO_BB=1; SRGB_TYPE=2; _HDTV_000255_; SRGB_320X240=1; NORMAL_VIDEO_QUALITY=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: rtos.bin
  ILINK.IlinkIcfFile: arkn141_demo.icf
  ILINK.IlinkExtraOptions: as above
configuration TULV_RGB480X854_JLINK (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; TULV=1; _HDTV_000255_; _SUPPORT_LCD_RGB_RM68172_; NORMAL_VIDEO_QUALITY=1; LCD_SIZE=10; LCD_ROTATE_90; RGB_848X480=1; ISP_SCALAR_USE_STATIC_FIFO; _XMSYS_TP_SUPPORT_; _XM_PROJ_=2; FLASH_3MB
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: rtos.bin
  ILINK.IlinkIcfFile: arkn141_tulv_480x800.icf
  ILINK.IlinkExtraOptions: as above
configuration HYBRID_H264_MJPG (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; ISP_3D_DENOISE_SUPPORT=0; _HDTV_000255_; NORMAL_VIDEO_QUALITY=1; HYBRID_H264_MJPG=1; CZS_USB_01=1; ENABLE_SENSOR_RESET
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: rtos.bin
  ILINK.IlinkIcfFile: arkn141_demo.icf
  ILINK.IlinkExtraOptions: as above
configuration SENSOR_BG0806_DEBUG (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; SENSOR_BG0806_DEBUG=1; _HDTV_000255_; NORMAL_VIDEO_QUALITY=1; _SUPPORT_TV_NTSC_; _SUPPORT_TV_PAL_; LCD_SIZE=7; ARKN141_CMOS_SENSOR=6; _XMSYS_UART_SOCKET_SUPPORT_; ISP_RAW_ENABLE; ISP_SCALAR_USE_STATIC_FIFO
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: rtos.bin
  ILINK.IlinkIcfFile: ark1960_SENSOR_DEBUG.icf
  ILINK.IlinkExtraOptions: as above
configuration SENSOR_AR0238_DEBUG (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; SENSOR_AR0238_DEBUG=1; _HDTV_000255_; NORMAL_VIDEO_QUALITY=1; _SUPPORT_TV_NTSC_; _SUPPORT_TV_PAL_; LCD_SIZE=7; ARKN141_CMOS_SENSOR=4; _XMSYS_UART_SOCKET_SUPPORT_; ISP_RAW_ENABLE; ISP_SCALAR_USE_STATIC_FIFO
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: rtos.bin
  ILINK.IlinkIcfFile: ark1960_SENSOR_DEBUG.icf
  ILINK.IlinkExtraOptions: as above
configuration TULV_BG0806 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; TULV=1; _HDTV_000255_; NORMAL_VIDEO_QUALITY=1; ISP_SCALAR_USE_STATIC_FIFO; FLASH_3MB; RGB_1024X600=1; LCD_SIZE=12; _XM_PROJ_=2; ROM_SPI=1; __XMSYS_UART_SOCKET_SUPPORT_; _JLINK_DISABLE; _XMSYS_RXCHIP_SUPPORT_
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\PowerPac\TCPIP\Inc\; $TOOLKIT_DIR$\PowerPac\RTOS\Inc\; ..\..\lib\ucfs\inc\; ..\..\rtos\inc\; ..\..\rtos\core\; ..\..\include\; ..\..\lib\usb\inc\; ..\..\lib\usb\inc\c8051\; ..\..\lib\usb\inc\class\; ..\..\lib\usb\src\cd\inc\; ..\..\lib\usb\src\drivers\hub\inc\; ..\..\lib\usb\src\drivers\ipod\inc\; ..\..\lib\usb\src\drivers\msd\inc\; ..\..\lib\usb\src\drivers\uvc\inc\; ..\..\lib\usb\src\functions\inc\; ..\..\lib\usb\src\systems\inc\; ..\..\rtos\board\
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: rtos.bin
  ILINK.IlinkIcfFile: arkn141_tulv_480x800.icf
  ILINK.IlinkExtraOptions: --image_input=..\..\rtos\core\dvr.jpg,_DVR_BIN_,_DVR_SECTION_,32
  ILINK.IlinkAdditionalLibs: ..\..\hwlib\libavcodec.a; ..\..\hwlib\libavformat.a; ..\..\hwlib\libavutil.a; ..\..\hwlib\aes.o
configuration HONGJING_CVBS_3D_OFF_JLINK (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; HONGJING_CVBS=1; _HDTV_000255_; NORMAL_VIDEO_QUALITY=1; _SUPPORT_TV_NTSC_; _SUPPORT_TV_PAL_; LCD_SIZE=7; ARKN141_CMOS_SENSOR=4; _XMSYS_UART_SOCKET_SUPPORT_; ISP_SCALAR_USE_STATIC_FIFO; FLASH_3MB
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: rtos.bin
  ILINK.IlinkIcfFile: arkn141_hongjing_cvbs.icf
  ILINK.IlinkExtraOptions: as above
configuration TULV_BB_IMX323 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG=1; TULV=1; _HDTV_000255_; _SUPPORT_LCD_RGB_RM68172_; NORMAL_VIDEO_QUALITY=1; LCD_SIZE=10; LCD_ROTATE_90; RGB_848X480=1; ISP_SCALAR_USE_STATIC_FIFO; _XMSYS_TP_SUPPORT_; TULV_BB_TEST
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\PowerPac\TCPIP\Inc\; $TOOLKIT_DIR$\PowerPac\RTOS\Inc\; ..\..\lib\ucfs\inc\; ..\..\rtos\inc\; ..\..\rtos\core\; ..\..\include\; ..\..\lib\musbstacks\include\; ..\..\lib\musbstacks\include\class\; ..\..\lib\musbstacks\src\cd\; ..\..\lib\musbstacks\src\drivers\hub\; ..\..\lib\musbstacks\src\drivers\msd\; ..\..\lib\musbstacks\src\drivers\uvc\; ..\..\lib\musbstacks\src\drivers\ipod\; ..\..\lib\musbstacks\src\systems\ucos\; ..\..\lib\musbstacks\src\systems\ucos\afs\; ..\..\lib\isp\exposure\; ..\..\lib\isp\sensor\; ..\..\lib\isp\
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: rtos.bin
  ILINK.IlinkIcfFile: arkn141_tulv_480x800.icf
  ILINK.IlinkExtraOptions: as above
  group (top)
    ../../app/: app_submenu_color.c app_submenu_datetime.c app_submenu_dec.c app_submenu_mot.c app_submenu_rec.c app_submenu_sys.c
    ./: main.c
  group app
    ../../app/: alert_view.c app.h app_albumlistview.c app_albummenu.c app_albumview.c app_button.c app_carbackline.c app_datetimesetting.c app_defaultparam.c app_factory.c app_format.c app_function.c app_guide.c app_guide_delay.c app_icon_library.c app_icon_library.h app_init.c app_main.c app_menudata.c app_menuid.c app_menuid.h app_menuoptionview.c app_messageview.c app_onekey_photograph.c app_playbackmenu.c app_process.h app_processview.c app_processview.h app_romimage.c app_settingview.c app_soundvolumeview.c app_switch_button.c app_systemupdate.c app_time.c app_titlebar.c app_version.c app_video.c app_video.h app_videolistview.c app_videosettingview.c app_videoview.c app_voice.c app_voice.h app_vol.c crc16.h desktop.c InitSetting.c recycle_video_alert_view.c system_check.c system_check.h SystemAPI.c systemapi.h xm_icon_manage.c
  group hwlib
    ../../hwlib/: lpng167.a speech_decoder_arm.a speech_decoder_thumb.a xm_motion_detector.a xm_rotate_lib.a zlib-1.2.8.a
  group include
    ../../include/: arkn141_jpeg_codec.h common_chardef.h common_chartype.h common_fontconst.h common_languageid.h common_string.h common_wstring.h hw_osd_layer.h xm_app_menudata.h xm_arkn141_isp_ae.h xm_assert.h xm_autotest.h xm_base.h xm_canvas.h xm_config.h xm_dev.h xm_file.h xm_gdi.h xm_h264_codec.h xm_heap_malloc.h xm_hybrid_stream.h xm_icon_manage.h xm_image.h xm_kernel_err_code.h xm_key.h xm_malloc.h xm_mci.h xm_message_socket.h xm_osd_framebuffer.h xm_osd_layer.h xm_osd_layer_animate.h xm_printf.h xm_proj_define.h xm_queue.h xm_recycle.h xm_rom.h xm_semaphore.h xm_systemupdate.h xm_tester.h xm_type.h xm_usbd_msc.h xm_user.h xm_video_task.h xm_videoitem.h xm_voice_prompts.h xm_widget.h
  group lib/cache_file
    ../../lib/cache_file/: xm_h264_cache_command_queue.c xm_h264_cache_file.c xm_h264_file.c
  group lib/codec
    ../../lib/codec/: arkn141_codec.c arkn141_codec_test.c arkn141_jpeg_test.c
  group lib/codec/dec/iar/dwl
    ../../lib/codec/dec/iar/dwl/: dwl_iar.c dwl_iar.h dwl_x170_iar_no_drv.c
  group lib/codec/dec/iar/ldriver
    ../../lib/codec/dec/iar/ldriver/: hx170dec.c hx170dec.h
  group lib/codec/dec/iar/test/h264
    ../../lib/codec/dec/iar/test/h264/: arkn141_h264_decoder.c arkn141_h264_decoder.h H264DecTestBench.c
  group lib/codec/dec/iar/test/jpeg
    ../../lib/codec/dec/iar/test/jpeg/: arkn141_jpeg_decoder.c arkn141_jpeg_decoder.h DecGetOption.c DecGetOption.h Jpegdectestbench.c JpegDecTestBench.h
  group lib/codec/dec/source/common
    ../../lib/codec/dec/source/common/: 8170enum.h 8170table.h bqueue.c bqueue.h decppif.h refbuffer.c refbuffer.h regdrv.c regdrv.h tiledref.c tiledref.h workaround.c workaround.h
  group lib/codec/dec/source/config
    ../../lib/codec/dec/source/config/: deccfg.h ppcfg.h
  group lib/codec/dec/source/h264high
    ../../lib/codec/dec/source/h264high/: h264_pp_multibuffer.h h264_pp_pipeline.c h264_pp_pipeline.h h264decapi.c h264decapi.h h264decapi_e.c h264decapi_e.h h264hwd_asic.c h264hwd_asic.h h264hwd_cabac.c h264hwd_cabac.h h264hwd_cavlc.c h264hwd_cavlc.h h264hwd_conceal.c h264hwd_conceal.h h264hwd_container.h h264hwd_decoder.c h264hwd_decoder.h h264hwd_dpb.c h264hwd_dpb.h h264hwd_exports.h h264hwd_image.h h264hwd_inter_prediction.c h264hwd_intra_prediction.c h264hwd_macroblock_layer.c h264hwd_macroblock_layer.h h264hwd_regdrv.h h264hwd_slice_data.c h264hwd_slice_data.h h264hwd_storage.c h264hwd_storage.h h264hwd_util.h
  group lib/codec/dec/source/h264high/legacy
    ../../lib/codec/dec/source/h264high/legacy/: h264hwd_byte_stream.c h264hwd_byte_stream.h h264hwd_cfg.h h264hwd_nal_unit.c h264hwd_nal_unit.h h264hwd_neighbour.c h264hwd_neighbour.h h264hwd_pic_order_cnt.c h264hwd_pic_order_cnt.h h264hwd_pic_param_set.c h264hwd_pic_param_set.h h264hwd_seq_param_set.c h264hwd_seq_param_set.h h264hwd_slice_group_map.c h264hwd_slice_group_map.h h264hwd_slice_header.c h264hwd_slice_header.h h264hwd_stream.c h264hwd_stream.h h264hwd_util.c h264hwd_vlc.c h264hwd_vlc.h h264hwd_vui.c h264hwd_vui.h
  group lib/codec/dec/source/inc
    ../../lib/codec/dec/source/inc/: basetype.h decapicommon.h dwl.h jpegdecapi.h mp4decapi.h mpeg2decapi.h on2rvdecapi.h ppapi.h rvdecapi.h vc1decapi.h vp6decapi.h vp8decapi.h
  group lib/codec/dec/source/jpeg
    ../../lib/codec/dec/source/jpeg/: jpeg_pp_pipeline.h jpegdecapi.c jpegdeccontainer.h jpegdechdrs.c jpegdechdrs.h jpegdecinternal.c jpegdecinternal.h jpegdecmarkers.h jpegdecscan.c jpegdecscan.h jpegdecutils.c jpegdecutils.h jpegregdrv.h
  group lib/codec/enc/iar/ewl
    ../../lib/codec/enc/iar/ewl/: ewl_x280_common.c ewl_x280_common.h ewl_x280_polling.c
  group lib/codec/enc/iar/kernel_module
    ../../lib/codec/enc/iar/kernel_module/: hx280enc.c hx280enc.h
  group lib/codec/enc/iar/test
    ../../lib/codec/enc/iar/test/: on2_TestBench.c
  group lib/codec/enc/iar/test/h264
    ../../lib/codec/enc/iar/test/h264/: arkn141_h264_encoder.c arkn141_h264_encoder.h arkn141_h264_encoder_test.c EncGetOption.c EncGetOption.h H264TestBench.c H264TestBench.h
  group lib/codec/enc/iar/test/integration
    ../../lib/codec/enc/iar/test/integration/: IntegrationTestRegister.c
  group lib/codec/enc/iar/test/jpeg
    ../../lib/codec/enc/iar/test/jpeg/: arkn141_jpeg_codec.h arkn141_jpeg_encoder.c EncGetOption.h JpegEncTestBench.c JpegEncTestBench.h
  group lib/codec/enc/inc
    ../../lib/codec/enc/inc/: basetype.h enccommon.h encswhwregisters.h ewl.h h264encapi.h h264encapi_ext.h jpegencapi.h vidstbapi.h
  group lib/codec/enc/source/camstab
    ../../lib/codec/enc/source/camstab/: vidstabalg.c vidstabapi.c vidstabcfg.h vidstabcommon.c vidstabcommon.h vidstabinternal.c vidstabinternal.h
  group lib/codec/enc/source/common
    ../../lib/codec/enc/source/common/: encasiccontroller.c encasiccontroller.h encasiccontroller_v2.c enccfg.h encpreprocess.c encpreprocess.h
  group lib/codec/enc/source/h264
    ../../lib/codec/enc/source/h264/: H264Cabac.c H264Cabac.h H264CabacContext.h H264CodeFrame.c H264CodeFrame.h H264EncApi.c h264encapi_ext.c H264Init.c H264Init.h H264Instance.h H264Mad.c H264Mad.h H264NalUnit.c H264NalUnit.h H264PictureParameterSet.c H264PictureParameterSet.h H264PutBits.c H264PutBits.h H264RateControl.c H264RateControl.h H264Sei.c H264Sei.h H264SequenceParameterSet.c H264SequenceParameterSet.h H264Slice.c H264Slice.h H264TestId.c H264TestId.h
  group lib/codec/enc/source/jpeg
    ../../lib/codec/enc/source/jpeg/: EncJpeg.c EncJpeg.h EncJpegCodeFrame.c EncJpegCodeFrame.h EncJpegCommon.h EncJpegDhtTables.h EncJpegInit.c EncJpegInit.h EncJpegInstance.h EncJpegMarkers.h EncJpegPutBits.c EncJpegPutBits.h EncJpegQuantTables.h JpegEncApi.c
  group lib/gif
    ../../lib/gif/: gif.c gif.h
  group lib/isp
    ../../lib/isp/: Gem_isp.c Gem_isp_ae.c Gem_isp_ae.h Gem_isp_awb.c Gem_isp_awb.h Gem_isp_colors.c gem_isp_colors.h Gem_isp_config.c Gem_isp_config.h Gem_isp_debug.c Gem_isp_denoise.c Gem_isp_denoise.h Gem_isp_enhance.c Gem_isp_enhance.h Gem_isp_eris.c Gem_isp_eris.h Gem_isp_fesp.c Gem_isp_fesp.h Gem_isp_io.c Gem_isp_io.h Gem_isp_sensor.h Gem_isp_sys.c Gem_isp_sys.h
  group lib/isp/exposure
    ../../lib/isp/exposure/: arkn141_isp_exposure.c arkn141_isp_exposure.h arkn141_isp_exposure_cmos.c arkn141_isp_exposure_cmos.h
  group lib/isp/sensor
    ../../lib/isp/sensor/: arkn141_cmos_sensor_bg0806.c arkn141_cmos_sensor_bg0806_io.c arkn141_isp_cmos_sensor_io.h arkn141_isp_sensor_cfg.h bg0806.c
    ../../lib/isp/: Gem_isp.h
  group lib/os_change_task
    ../../lib/os_change_task/: os_change_task.c
  group lib/png
    ../../lib/png/: png.c png.h pngconf.h pngdebug.h pngerror.c pngget.c pnginfo.h pnglibconf.h pngmem.c pngpread.c pngpriv.h pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngstruct.h pngtrans.c pngwio.c pngwrite.c pngwtran.c pngwutil.c
  group lib/ucfs/config
    ../../lib/ucfs/Config/: ConfigDrive.c FS_X_Panic.c
  group lib/ucfs/FS/Core
    ../../lib/ucfs/FS/Core/: FS__ECC256.c FS_AddSpaceHex.c FS_AssignCache.c FS_Attrib.c FS_CacheAll.c FS_CacheMan.c FS_CacheRW.c FS_CacheRWQuota.c FS_CLib.c FS_CopyFile.c FS_Core.c FS_CreateDir.c FS_Dir.c FS_DirOld.c FS_ErrorNo2Text.c FS_ErrorOut.c FS_Format.c FS_FRead.c FS_FWrite.c FS_GetFilePos.c FS_GetFileSize.c FS_GetNumFiles.c FS_GetNumOpenFiles.c FS_Journal.c FS_Log.c FS_LogBlock.c FS_LogVolume.c FS_memcpy.c FS_Misc.c FS_Move.c FS_OS_Interface.c FS_Partition.c FS_Read.c FS_Rename.c FS_SetEndOfFile.c FS_SetFilePos.c FS_Storage.c FS_Time.c FS_Truncate.c FS_Unmount.c FS_Verify.c FS_Volume.c FS_Warn.c FS_Write.c ucFS_Version.c
  group lib/ucfs/FS/Driver/SD_MMC
    ../../lib/ucfs/FS/Driver/SD_MMC/: SD_MMC1_Drive.c SD_MMC_Drive.c
  group lib/ucfs/FS/FSL/FAT
    ../../lib/ucfs/FS/FSL/FAT/: FAT_API.c FAT_CheckDisk.c FAT_Dir.c FAT_DirEntry.c FAT_DiskInfo.c FAT_Format.c FAT_FormatSD.c FAT_FreeCluster.c FAT_GetFileClusterSectorInfo.c FAT_Ioct.c FAT_LFN.c FAT_Misc.c FAT_Move.c FAT_Open.c FAT_Read.c FAT_Rename.c FAT_SetEndOfFile.c FAT_VolumeLabel.c FAT_Write.c
  group lib/ucfs/Inc
    ../../lib/ucfs/Inc/: FAT.h FAT_Intern.h fs.h FS_API.h FS_CLib.h FS_Conf.h FS_ConfDefaults.h FS_Debug.h FS_Dev.h FS_DF_X_HW.h FS_Int.h FS_Lbl.h FS_OS.h FS_Port.h FS_Storage.h FS_Types.h Global.h IDE_X_HW.h MMC_SD_CardMode_X_HW.h MMC_X_HW.h ucFS_Version.h
  group lib/usb/cd
    ../../lib/usb/src/cd/: mu_cntlr.c mu_descs.c mu_drc.c mu_fadma.c mu_fc.c mu_fdr.c mu_fun.c mu_funex.c mu_hc.c mu_hdr.c mu_hfc.c mu_hsdma.c mu_hst.c mu_list.c mu_mdr.c mu_pip.c
  group lib/usb/drivers/hub
    ../../lib/usb/src/drivers/hub/: mu_hapi.c mu_hcore.c mu_hcreq.c mu_hub.c
  group lib/usb/drivers/ipod
    ../../lib/usb/src/drivers/ipod/: mu_iapi.c mu_ictrl.c
  group lib/usb/drivers/msd
    ../../lib/usb/src/drivers/msd/: mu_mapi.c mu_mbot.c mu_mscsi.c
  group lib/usb/drivers/uvc
    ../../lib/usb/src/drivers/uvc/: mu_uapi.c mu_uctrl.c
  group lib/usb/functions
    ../../lib/usb/src/functions/: mu_tfunc.c
  group lib/usb/lib
    ../../lib/usb/src/lib/: mu_bits.c mu_ramfl.c mu_stack.c mu_stdio.c mu_strng.c
  group lib/usb/systems
    ../../lib/usb/src/systems/: board.c mu_hfios.c mu_sys.c
  group lib/uvc
    ../../lib/uvc/: AudioFunction.c CdrRequest.c common.h descript.c descript.h descript_def.c descript_def.h globaldata.c globalfunc.c gpio_function.c gpio_function.h hardware.h interrupt.c musbdefs.h pc_main.c requests.h SensorCommon.c sensorcommon.h sensorlib.c sensorlib.h UsbRequest.c UvcRequest.c UvcVideo.c VideoFunction.c xm_hybrid_stream.c
  group lib/videoitem
    ../../lib/videoitem/: common_rbtr.c common_rbtr.h xmvideoitem.c
  group middleware/common
    ../../middleware/common/: common_chardef.c common_chartype.c common_string.c common_wstring.c xm_recycle.c
  group middleware/gdi
    ../../middleware/gdi/: xm_argb32bpp_drv.c xm_canvas.c xm_device.h xm_fb_argb454_drv.c xm_fb_argb888_drv.c xm_fb_drv.c xm_fb_rgb565_drv.c xm_file.c xm_gdi_device.h xm_gdi_graph.c xm_gdi_image.c xm_gdi_rom_image.c xm_gui_res.h xm_kbd_drv.c xm_osd_framebuffer.c xm_osd_framebuffer_config.c xm_osd_layer.c xm_osd_layer_animate.c xm_osd_layer_gif.c xm_osd_layer_gif.h xm_rgb16bpp_drv.c xm_time_drv.c xm_uart_drv.c xm_uvc_mem.c xm_win_base.c xm_win_gdi.c xm_win_main.c xm_win_mem.c xm_win_user.c xm_win_widget.c xm_xml.c
  group rtos/board
    ../../rtos/board/: board_4recfg_rgb888_V1.c
  group rtos/core
    ../../rtos/core/: app_task.c app_uvc_task.c avi_codec_task.c avi_codec_video_setting.h avio.c camera_task.c cortex_a5_board_cstartup_iar.s cortex_a5_cp15.c cortex_a5_cp15.h cortex_a5_cp15_asm_iar.s cortex_a5_mmu.c cortex_a5_mmu.h exception_dump.c hardtimer_task.c hongjing_uart_socket.c jpeg_task.c message_task.c onekeyphotograph_task.c OS_Error.c queue.c rtosinit.c sensor_task.c target.c target_ucosii.c Uart_Protocal.c Uart_Protocal.h xm_core_file.c xm_core_linear_memory.c xm_Det_task.c xm_edog_socket_zcwy.c xm_file_manager_task.c xm_motion_detector_task.c xm_semaphore.c xm_system_update.c xm_uart_socket.c xm_uvc_socket.c xm_uvc_socket.h xm_video_task.c
  group rtos/driver
    ../../rtos/driver/remote/: remote.c
  group rtos/driver/acc
    ../../rtos/driver/acc/: acc_detect.c trigger_array_stack.c trigger_detect.c
  group rtos/driver/adc
    ../../rtos/driver/adc/: adc.c adc.h xm_adc.c
  group rtos/driver/clock
    ../../rtos/driver/clock/: clock.c
  group rtos/driver/cpu_clk_counter
    ../../rtos/driver/cpu_clk_counter/: CpuClkCounter.c
  group rtos/driver/deinterlace
    ../../rtos/driver/Deinterlace/: deinterlace.c
  group rtos/driver/dma
    ../../rtos/driver/dma/: dma.c
  group rtos/driver/g_sensor
    ../../rtos/driver/g_sensor/: g_sensor.c
  group rtos/driver/gpio
    ../../rtos/driver/gpio/: gpio.c
  group rtos/driver/i2c
    ../../rtos/driver/i2c/: gpioi2c.c xm_i2c.c
  group rtos/driver/i2s
    ../../rtos/driver/i2s/: xm_iisadc.c
  group rtos/driver/irq
    ../../rtos/driver/irq/: irq.c
  group rtos/driver/isp_scale
    ../../rtos/driver/isp_scale/: isp_scale.h xm_isp_scalar.c xm_isp_scaler_itu601.c
  group rtos/driver/itu656
    ../../rtos/driver/itu656/: itu656.c itu656.h itu656_test.c xm_itu656_in.c
  group rtos/driver/led
    ../../rtos/driver/led/: xm_led.c
  group rtos/driver/mtd
    ../../rtos/driver/mtd/sdmmc/: sdmmc.c
  group rtos/driver/power
    ../../rtos/driver/power/: xm_power.c
  group rtos/driver/pwm
    ../../rtos/driver/pwm/: pwm.c
  group rtos/driver/rtc
    ../../rtos/driver/rtc/: calender.c calender.h rtc.c
  group rtos/driver/scale
    ../../rtos/driver/scale/: arkn141_scale.c
  group rtos/driver/ssi
    ../../rtos/driver/ssi/: ssi.c
  group rtos/driver/timer
    ../../rtos/driver/timer/: timer.c
  group rtos/driver/tp
    ../../rtos/driver/tp/: flash.c icn85xx.h icn85xx_fw.h icn87xx_fw.h tp_gt9xx.c tp_icn85xx.c tp_icn85xx.h tpd_custom_icn85xx.h
  group rtos/driver/uart
    ../../rtos/driver/uart/: crc16.c uart.c uart.h xm_uart.c
  group rtos/driver/video
    ../../rtos/driver/video/: hdmi.c hw_osd_layer_iar.c lcd.c lcdc_rgb.c tv_ntsc.c tv_pal.c
    ../../rtos/driver/decoder/: rxchip.c
    ../../middleware/gdi/: xm_touch_drv .c
  group rtos/driver/video/HDMI
    ../../rtos/driver/video/hdmi/: config.h csc.c debug.h hdmi_i2c.c hdmi_main.c hdmitx.h hdmitx_drv.c hdmitx_drv.h hdmitx_hdcp.c hdmitx_hdcp.h hdmitx_input.c hdmitx_input.h hdmitx_sys.c hdmitx_sys.h IO.c IO.h sha1.c sha1.h typedef.h
  group rtos/driver/watchdog
    ../../rtos/driver/watchdog/: wdt.c
  group rtos/fs
    ../../rtos/fs/: fs_cache_file_test.c FS_OS.c fs_sd1_test.c fs_sd_test.c
  group rtos/iar_lib
    $EW_DIR$/arm/PowerPac/RTOS/Lib/: os5t_al__d.a
  group rtos/inc
    ../../rtos/inc/: app_head.h ark1960.h ark1960_testcase.h arkn141_codec.h arkn141_isp.h arkn141_scale.h bits.h CdrRequest.h clock.h common.h cpuClkCounter.h crc16.h deinterlace.h dma.h fs_card.h gpio.h gpioi2c.h hardware.h irqs.h lcd.h printk.h pwm.h remote.h rtc.h sdmmc.h ssi.h sys_soft_reset.h timer.h types.h uart.h watchdog.h xm_adc.h xm_core.h xm_core_linear_memory.h xm_file_manager_task.h xm_flash_space_define.h xm_h264_cache_command_queue.h xm_h264_cache_file.h xm_h264_file.h xm_i2c.h xm_isp_scalar.h xm_itu656_in.h xm_kernel_malloc.h xm_power.h xm_uart.h xm_uvc_video.h
